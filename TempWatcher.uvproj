# Keil uVision project TempWatcher.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TempWatcher +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c Driver_LCD1602.c I2C.c SingleWire.c Delay.c Driver_AT24C02.c Driver_DS18B20.c GetKey.c Timer.c UART.c
